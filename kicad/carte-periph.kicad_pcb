# Repository ERACL/carte-capteur

File README.md:

Carte standard périphériques
============================

Carte standard périphériques - Contient la CAO KiCAD de la carte pour les périphériques

## KiCad design kicad/carte-periph.kicad_pcb

Parts:
C1, C2: 17p; C_Rect_L4.6mm_W2.0mm_P2.50mm_MKS02_FKP02
C3, C5, C8, C10, C12: 100n; C_Rect_L4.6mm_W2.0mm_P2.50mm_MKS02_FKP02
C4, C6: 100u; CP_Radial_D5.0mm_P2.50mm
C7: 10u; CP_Radial_D5.0mm_P2.50mm
C9, C11, C13: 1u; CP_Radial_D5.0mm_P2.50mm
D1: RED; LED_D3.0mm
D2: ORANGE; LED_D3.0mm
D3: GREEN; LED_D3.0mm
J1: PDB; Measurement_Point_Round-TH_Small
J2: PWR_IN; Molex_MiniFit-JR-5569-04A2_2x02x4.20mm_Angled
J3: PROG; Pin_Header_Straight_2x05_Pitch2.54mm
J8, J9: I2C; KK_2C
R1: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2, R3, R4: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
U1: Conn_periph; conn_periph
U2: PIC24FJ128GA104; TQFP-44_10x10mm_Pitch0.8mm
Y1: 10MHz; Crystal_HC18-U_Vertical

Connections:
+3V3: C5.2, C6.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, J2.3, J3.4, R1.2, R3.2, U1.V31 (3.3V), U1.V32 (3.3V), U1.V33 (3.3V), U2.17 (AVDD), U2.28 (VDD), U2.40 (VDD)
+5V: C3.2, C4.1, J2.2, J3.3, R2.2, U1.V51 (5V), U1.V52 (5V), U1.V53 (5V)
/DEBUG_RX: J3.7, U2.14 (RB14)
/DEBUG_TX: J3.5, U2.15 (RB15)
/I2C_CLK1: J8.1, J9.1, U2.44 (RB8)
/I2C_DATA1: J8.2, J9.2, U2.1 (RB9)
/Mclr: J3.2, R1.1, U2.18 (MCLR)
/PCK: J3.10, U2.9 (RB11)
/PDB: J1.1, J3.9
/PDT: J3.8, U2.8 (RB10)
/RA0: U1.A0 (RA0), U2.19 (RA0)
/RA1: U1.A1 (RA1), U2.20 (RA1)
/RA4: R4.2, U2.34 (RA4)
/RA7: U1.A7 (RA7), U2.13 (RA7)
/RA8: U1.A8 (RA8), U2.32 (RA8)
/RA9: U1.A9 (RA9), U2.35 (RA9)
/RA10: U1.A10 (RA10), U2.12 (RA10)
/RB0: U1.B0 (RB0), U2.21 (RB0)
/RB1: U1.B1 (RB1), U2.22 (RB1)
/RB2: U1.B2 (RB2), U2.23 (RB2)
/RB3: U1.B3 (RB3), U2.24 (RB3)
/RB4: U1.B4, U2.33 (RB4)
/RB5: U1.B5 (RB5), U2.41 (RB5)
/RB6: U1.B6 (RB6), U2.42 (RB6)
/RB7: U1.B7 (RB7), U2.43 (RB7)
/RB12: U1.B12 (RB12), U2.10 (RB12)
/RB13: U1.B13 (RB13), U2.11 (RB13)
/RC0: U1.C0 (RC0), U2.25 (RC0)
/RC1: U1.C1 (RC1), U2.26 (RC1)
/RC2: U1.C2 (RC2), U2.27 (RC2)
/RC3: U1.C3 (RC3), U2.36 (RC3)
/RC4: U1.C4 (RC4), U2.37 (RC4)
/RC5: U1.C5 (RC5), U2.38 (RC5)
/RC6: U1.C6 (RC6), U2.2 (RC6)
/RC7: U1.C7 (RC7), U2.3 (RC7)
/RC8: U1.C8 (RC8), U2.4 (RC8)
/RC9: U1.C9 (RC9), U2.5 (RC9)
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, D1.1 (K), D2.1 (K), D3.1 (K), J2.1, J3.6, U1.G1 (GND), U1.G2 (GND), U1.G3 (GND), U1.G4 (GND), U1.G5 (GND), U1.G6 (GND), U2.6 (DISVREG), U2.16 (AVSS), U2.29 (VSS), U2.39 (VSS)
unnamed: C1.1, U2.30 (RA2), Y1.2
unnamed: C2.1, U2.31 (RA3), Y1.1
unnamed: C7.1, U2.7 (VCAP/VDDCORE)
unnamed: D1.2 (A), R2.1
unnamed: D2.2 (A), R3.1
unnamed: D3.2 (A), R4.1

Notes on the sheet:
Témoins d'alimentation
Connecteur d'alimentation
Convensions couleurs : 1 - Noir : masse 2 - Rouge : +5V 3 - Orange : +3.3V 4 - Jaune : BATT
Lissage tensions
Capacités de protection
I2C
Témoin processeur
Processeur de contrôle des périphériques
Connecteur de programmation
Connecteurs du shield

Board: 2 copper layers, 80.0 x 72.4 mm, 28 parts (0 on the bottom side), 44 nets.

## KiCad design kicad/carte-capteur.kicad_pcb

Parts:
C1, C2: 17p; C_Rect_L7.0mm_W3.5mm_P2.50mm_P5.00mm
C3, C5, C8, C10: 100n; C_Rect_L7.0mm_W3.5mm_P2.50mm_P5.00mm
C4, C6: 100u; CP_Radial_D10.0mm_P2.50mm_P5.00mm
C7: 10u; CP_Radial_D10.0mm_P2.50mm_P5.00mm
C9, C11: 1u; CP_Radial_D10.0mm_P2.50mm_P5.00mm
D1: RED; LED_D3.0mm
D2: ORANGE; LED_D3.0mm
D3: GREEN; LED_D3.0mm
J1: PDB; Measurement_Point_Round-TH_Small
J2: PWR_IN; Molex_MiniFit-JR-5569-04A2_2x02x4.20mm_Angled
J3: PROG; Pin_Header_Straight_2x05_Pitch2.54mm
J4, J5, J6, J7: Fix; MountingHole_3.2mm_M3_Pad
J8, J9: I2C; KK_2C
R1: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2, R3, R4: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R5, R6: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
U1: PIC24FJ128GA202; DIP-28_W7.62mm
U2: Shield_gauche; conn_shield
U3: Shield_droit; conn_shield
Y1: 10MHz; Crystal_HC18-U_Vertical

Connections:
+3V3: C5.2, C6.1, C8.1, C9.1, C10.1, C11.1, J2.3, J3.4, R1.2, R3.2, R5.1, R6.2, U1.13, U1.28, U2.2, U3.2
+5V: C3.2, C4.1, J2.2, R2.2, U2.3, U3.3
/DEBUG_RX: J3.7, U1.21
/DEBUG_TX: J3.5, U1.22
/I2C_CLK1: J8.1, J9.1, U1.17
/I2C_CLK2: R5.2, U1.7, U3.8
/I2C_DATA1: J8.2, J9.2, U1.18
/I2C_DATA2: R6.1, U1.6, U3.9
/Mclr: J3.2, R1.1, U1.1
/PCK: J3.10, U1.5
/PDB: J1.1, J3.9
/PDT: J3.8, U1.4
/RA0: U1.2, U2.4
/RA1: U1.3, U2.5
/RA4: R4.2, U1.12
/RA7: U2.11
/RA8: U2.12
/RA9: U2.13
/RA10: U2.14
/RB4: U1.11, U2.6
/RB5: U1.14, U2.7
/RB6: U1.15, U2.8
/RB7: U1.16, U2.9
/RB12: U1.23, U3.4
/RB13: U1.24, U3.5
/RB14: U1.25, U3.6
/RB15: U1.26, U3.7
/RC0: U2.15
/RC1: U2.16
/RC2: U2.17
/RC3: U3.11
/RC4: U3.12
/RC5: U3.13
/RC6: U3.14
/RC7: U3.15
/RC8: U3.16
/RC9: U3.17
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, D1.1 (K), D2.1 (K), D3.1 (K), J2.1, J3.6, U1.8, U1.19, U1.27, U2.1, U2.10, U2.18, U3.1, U3.10, U3.18
unnamed: C1.1, U1.9, Y1.2
unnamed: C2.1, U1.10, Y1.1
unnamed: C7.1, U1.20
unnamed: D1.2 (A), R2.1
unnamed: D2.2 (A), R3.1
unnamed: D3.2 (A), R4.1

Notes on the sheet:
Trous fixation
Témoins d'alimentation
Connecteur d'alimentation
Convensions couleurs : 1 - Noir : masse 2 - Rouge : +5V 3 - Orange : +3.3V 4 - Jaune : BATT
Lissage tensions
Capacités de protection
Bus I2C avec pull up pour les peripheriques
I2C RASPBERRY
Témoin processeur
Processeur de contrôle des périphériques
Connecteur de programmation
Connecteurs du shield

Board: 4 copper layers, 33 parts (0 on the bottom side), 30 nets.

## Commit log

2018-02-13 Mise en forme du fichier README.md
2018-02-13 Création du projet KiCAD
2018-03-07 Ajout d'empreintes pour le PIC et les connecteurs de shield
2018-03-07 Schéma électrique à valider
    Soucis au niveau des PWR_FLAG + pins non connectées en prévision de la prochaine itération
2018-03-07 Ajout empreintes connecteurs
2018-03-07 Association empreintes
2018-03-13 Premier jet typon
2018-03-13 Mise à jour du fichier README.md en vue du changement de nom
2018-03-13 Mise à jour des noms
2018-03-20 Passage en 2 couches
2018-03-22 Enlèvement des résistances de pull up I2C
2018-03-24 Mise au propre
2018-04-10 Changement du PIC et rajout d'une empreinte de connecteur
2018-04-18 Validation carte, à passer en release
2018-04-18 Modification pads connecteurs shield
2018-04-20 Ajout du contenu du fichier export à la liste des fichiers ignorés
2018-04-20 Retouche des connecteurs I2C et ajout du 5V sur le connecteur de programmation
2018-04-20 Modification taille trous KK2C
2018-04-22 Ajout des fichiers Gerber aux fichiers ignorés
2018-04-22 Fixed untracked files
2018-04-22 Mise à jour des cartouches en vue de la release
